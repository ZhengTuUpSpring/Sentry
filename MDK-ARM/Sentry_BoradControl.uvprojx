# Keil uVision project Sentry_BoradControl.uvprojx, settings and files
target Sentry_BoradControl (5060528::V5.06 update 5 (build 528)::C:\Keil_v5\ARM\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Sentry_BoradControl +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USER_ALL/application;../USER_ALL/Bsp;../USER_ALL/controller;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../USER_ALL/Task;../USER_ALL/DSP/Include/dsp;../USER_ALL/DSP/Include;../USER_ALL/DSP/Source;../USER_ALL/DSP;../USER_ALL/BMI088_use;..\USER_ALL\Judging_System
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group controller
    ../USER_ALL/controller/: pid.c pid.h 4310_control.c 4310_control.h control_3508.c control_3508.h
  group application
    ../USER_ALL/application/: apply_4310.c apply_4310.h RC_control.c RC_control.h chassis_control.h chassis_control.c limit_power_control.c limit_power_control.h chassis_angle_calculation.c chassis_angle_calculation.h
  group Bsp
    ../USER_ALL/Bsp/: struct_typedef.h bsp_can.c bsp_can.h bsp_dji.c bsp_dji.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Task
    ../USER_ALL/Task/: receive_Task.c receive_task.h chasis_task.c chasis_task.h nav_task.c nav_task.h Judging_System_Task.c Judging_System_Task.h
  group DSP
    ../USER_ALL/DSP/: arm_cortexM4lf_math.lib arm_sin_cos.c
  group BMI088_use
    ../USER_ALL/BMI088_use/: BMI088.c BMI088.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h bsp_dwt.c bsp_dwt.h
  group Judging_System
    ../USER_ALL/Judging_System/: Judging_System_Bsp.c Judging_System_Bsp.h Judging_System_Handler.c Judging_System_Handler.h RingBuffer.c RingBuffer.h
software components: CMSIS:CORE 4.3.0
