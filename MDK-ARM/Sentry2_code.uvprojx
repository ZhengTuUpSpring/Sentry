# Keil uVision project Sentry2_code.uvprojx, settings and files
target Sentry2_code (5060528::V5.06 update 5 (build 528)::C:\Keil_v5\ARM\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Sentry2_code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bsp;../Application;../Controller;../DSP/Include;../DSP/Source;../Drivers/CMSIS/DSP/Source;../Drivers/CMSIS/DSP/PrivateInclude;../Task;../VIM;../DEMO
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: Sentry2_code\Sentry2_code.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Bsp
    ../Bsp/: bsp_can.c bsp_can.h driver_3508.c driver_3508.h can_receive.c can_receive.h Filiter.c Filiter.h driver_2006.c driver_2006.h driver_6020.c driver_6020.h driver_4310.c driver_4310.h jy901.c example_data.c hipnuc_dec.c nmea_dec.c 4310_apply.c 4310_apply.h
  group Controller
    ../Controller/: pid.c pid.h Angle_limit.c Angle_limit.h pid_control.c pid_control.h
  group Application
    ../Application/: gimbalControl.c gimbalControl.h Sliding.c Sliding.h shootControl.c shootControl.h remoteControl.c remoteControl.h autoControl.c autoControl.h
  group Dsp_lib
    ../DSP/Source/ControllerFunctions/: arm_sin_cos_f32.c
    ../DSP/: arm_cortexM4lf_math.lib
  group Task
    ../Task/: gimbal_task.c hipnuc_imu_task.c rc_task.c ReceiveBaseboard_task.c SendBaseboard_task.c shoot_task.c gimbaltaskC.c
  group VIM
    ../VIM/: VTM03_Bsp.c VTM03_Handler.c RingBuffer.c
  group demo
    ../DEMO/: vofa.c vofa.h
software components: CMSIS:CORE 6.1.1
